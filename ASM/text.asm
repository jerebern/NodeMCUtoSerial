
;===========================================================================================================================================================================			
;										Print String
;===========================================================================================================================================================================		 
Print_String                           PROC NEAR			


			str			  EQU	   <WORD PTR[BP+4]>		
	
			
			PUSH BP
			MOV BP,SP
			PUSH AX
	
			
			MOV AH,09h
			MOV DX,str					;printf("%s",str);
			INT 21H
					
			MOV AH,02H
			MOV DL,10					;printf("\n")
			INT 21H	
			
			MOV AH,02H
			MOV DL,13					;printf(13)
			INT 21h			
			
			POP AX	
			MOV SP,BP
			POP BP
			RET							;return
	
Print_String                          ENDP 		

;===========================================================================================================================================================================			
;										\ Print String /	
;===========================================================================================================================================================================		 
	
;===========================================================================================================================================================================			
;										Print String no space
;===========================================================================================================================================================================		 
Print_String_no_space                           PROC NEAR			


			str			  EQU	   <WORD PTR[BP+4]>		
	
			
			PUSH BP
			MOV BP,SP
			PUSH AX
			
			MOV AH,02H
			MOV DL,10					;printf("\n")
			INT 21H	
			
			MOV AH,02H
			MOV DL,13					;printf(13)
			INT 21h	
	
			
			MOV AH,09h
			MOV DX,str					;printf("%s",str);
			INT 21H
	
			
			POP AX	
			MOV SP,BP
			POP BP
			RET							;return
	
Print_String_no_space                          ENDP 		

;===========================================================================================================================================================================			
;										\ Print String no space /	
;===========================================================================================================================================================================		 
	
